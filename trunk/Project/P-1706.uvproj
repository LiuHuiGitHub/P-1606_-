# Keil uVision project P-1706.uvproj, settings and files
target project (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: P-1706 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\System;..\User;..\Hwa;..\Drivers;..\App
  link misc: REMOVEUNUSED
  group System
    ../System/: sys_eeprom.c sys_delay.c
  group User
    ../User/: main.c
  group Hwa
    ../Hwa/: hwa_mifare.c hwa_eeprom.c hwa_eeprom_cfg.c
  group Driver
    ../Drivers/: mifare.c drive_buzzer.c drive_led.c drive_relay.c drive_key.c
  group App
    ../App/: app_brush.c app_config.c app_time.c app_test.c
